# Keil uVision project MEMS_STM32F103RG.uvprojx, settings and files
target MEMS_STM32F103RG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MEMS_STM32F103RG
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xG
  c include: ../Inc;           ../Drivers/STM32F1xx_HAL_Driver/Inc;           ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;           ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;           ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f103xg.s
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group Application/User
    ../Src/: usart.c main.c gpio.c stm32f1xx_hal_msp.c stm32f1xx_it.c tim.c stm32f1xx_hal_timebase_TIM.c bsp_driver_led.c i2c.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_pwr.c stm32f1xx_hal_gpio.c stm32f1xx_hal_tim.c stm32f1xx_hal.c stm32f1xx_hal_flash.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_uart.c stm32f1xx_hal_i2c.c
  group Device
    ../Src/: MTi-1_series.c bsp_bmp280_i2c.c device.c
software components: CMSIS:CORE 4.3.0
